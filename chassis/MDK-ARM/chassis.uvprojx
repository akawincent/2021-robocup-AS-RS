# Keil uVision project chassis.uvprojx, settings and files
target chassis (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F750V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: chassis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ../Core/Inc;                                        ../Drivers/STM32F7xx_HAL_Driver/Inc;                                        ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                                        ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                                        ../Drivers/CMSIS/Include;                                        ..\Driver;                                        ..\Module;                                        ..\Math;                                        ..\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Driver
    ../driver/: motor_encoder.c motor_pwm.c motor_config.c
    ../Driver/: time_cnt.c turnover_steering.c bsp_delay.c
  group Module
    ../Module/: motor.c imu.c trackboard.c qrcode.c ats522.c lsc.c openmv.c
  group Math
    ../Math/: pid.c
  group Task
    ../Task/: motor_task.c imu_task.c track_task.c avoid_obj_task.c walk_task.c turntable_task.c catch_task.c put_task.c stack_transfer.c stake_task.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
